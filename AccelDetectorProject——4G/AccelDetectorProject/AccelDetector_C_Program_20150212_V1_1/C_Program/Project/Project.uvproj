# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\FWLib\CMSIS\CM3\CoreSupport;..\FWLib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\FWLib\STM32F10x_StdPeriph_Driver\inc;..\MAIN\MAIN;..\MAIN\DELAY;..\BSP\CONFIG;..\BSP\RCC;..\BSP\NVIC;..\BSP\ISR;..\BSP\GPIO;..\BSP\KEY;..\BSP\LED;..\BSP\TIM;..\BSP\USART;..\BSP\RTC;..\BSP\MPU6000;..\BSP\SDCard;..\FATFS\src;..\BSP\LCD;..\uC-GUI\Config;..\uC-GUI\LCDDriver;..\uC-GUI\GUI\ConvertColor;..\uC-GUI\GUI\ConvertMono;..\uC-GUI\GUI\Core;..\uC-GUI\GUI\Font;..\uC-GUI\GUI\AntiAlias;..\uC-GUI\GUI_X;..\Menu;..\APP;..\MPU60X0_DMP;..\MAIN\QUEUE;..\BSP\IR;..\BSP\BAT;..\BSP\ADC;..\BSP\FLASH;..\MAIN\QUEUE;..\MAIN\FILTER;..\BSP\sim7100c;..\FATFS\exfuns;..\FATFS\src;..\FATFS;..\FATFS\doc;..\MALLOC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../FWLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../FWLib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../FWLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FWLib
    ../FWLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_dma.c
  group BSP
    ../BSP/RCC/: rcc.c
    ../BSP/NVIC/: nvic.c
    ../BSP/TIM/: tim.c
    ../BSP/USART/: usart.c
    ../BSP/ADC/: adc.c
    ../BSP/LED/: led.c
    ../BSP/KEY/: key.c
    ../BSP/ISR/: stm32f10x_it.c
    ../BSP/RTC/: rtc.c
    ../BSP/FLASH/: flash.c
    ../BSP/MPU6000/: mpu6000.c
    ../BSP/SDCard/: sdcard.c
    ../BSP/LCD/: lm240120.c
    ../APP/: menu.c item.c
    ../BSP/IR/: ir.c
    ../BSP/sim7100c/: sim900a.c
  group MAIN
    ../MAIN/MAIN/: main.c
    ../MAIN/DELAY/: delay.c
    ../APP/: param.c disp.c
    ../BSP/LCD/: graph.c
    ../MAIN/QUEUE/: Queue.c
    ../MAIN/FILTER/: filter.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: exfuns.c
  group MPU60X0_DMP
    ../MPU60X0_DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group MALLOC
    ../MALLOC/: malloc.c
